# Keil uVision project CtrBoard-H7_ALL.uvprojx, settings and files
target CtrBoard-H7_ALL (5060960::V5.06 update 7 (build 960)::.\armcc_5)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2404FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: CtrBoard-H7_ALL +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32H723xx,USE_PWR_LDO_SUPPLY
  c include: ../Core/Inc;../USB_DEVICE/App;../USB_DEVICE/Target;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Middlewares/ST/AI/Inc;../X-CUBE-AI/App;../Middlewares/ST/ARM/DSP/Inc;../imcalib/drivers/inc;../imcalib/bsp/inc;../imcalib/common/inc;../imcalib/config;../imcalib/Algorithm/lqr/inc;../imcalib/Algorithm/rl/inc;../imcalib/Algorithm/estimation/inc;../imcalib/Algorithm/detection/inc;../imcalib/Algorithm/process/inc;../imcalib/Algorithm/compensation/inc;../imcalib/task/inc;../imcalib/task/control/inc;../imcalib/task/service/inc
  asm include: ../Core/Inc;../Drivers/CMSIS/Include;../Middlewares/ST/ARM/DSP/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x50000
  scatter file: CtrBoard-H7_ALL.sct
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Application/User/USB_DEVICE/App
    ../USB_DEVICE/App/: usb_device.c usbd_desc.c usbd_cdc_if.c
  group Application/User/USB_DEVICE/Target
    ../USB_DEVICE/Target/: usbd_conf.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_ll_usb.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_cortex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
  group imcalib/drivers
    ../imcalib/drivers/: BMI088driver.c dji.c dm.c dr16.c hi229.c ws2812.c
  group imcalib/bsp
    ../imcalib/bsp/: latency_capture.c output_capture.c latency_usb.c BMI088Middleware.c can_bus.c mono_ns.c uart_idle.c Vofa_send.c
    ../USB_DEVICE/App/: jetson_usb.c
  group imcalib/common
    ../imcalib/common/: simple-function.c kalman.c arm_sin_f32.c arm_cos_f32.c arm_sin_table_f32.c pid.c
  group imcalib/config
    ../imcalib/config/: machine_config.c
  group imcalib/Algorithm/lqr
    ../imcalib/Algorithm/lqr/: lqr_gain_big.c leg_balance.c roll_height_model.c roll_height_balance.c lqr_balance.c motion_guard.c lqr_gain_table.c
  group imcalib/Algorithm/estimation
    ../imcalib/Algorithm/estimation/: Attitude_Algorithm.c leg_solver.c slip.c pitch_world.c
  group imcalib/Algorithm/rl
    ../imcalib/Algorithm/rl/: rl_observation.c rl_torque.c
  group imcalib/Algorithm/compensation
    ../imcalib/Algorithm/compensation/: gas_spring.c gravity_comp.c leg_compensation.c
  group imcalib/Algorithm/detection
    ../imcalib/Algorithm/detection/: air_detection.c stair_detection.c control_condition.c fallen_detection.c
  group imcalib/Algorithm/process
    ../imcalib/Algorithm/process/: fallen_process.c stair_process.c air_process.c
  group imcalib/task
    ../imcalib/task/: robot_control.c task_imu.c task_policy.c task_actuation.c task_comm.c background_service.c
  group imcalib/task/control
    ../imcalib/task/control/: control_detection.c control_strategy.c control_compute.c control_output.c
  group imcalib/task/service
    ../imcalib/task/service/: vofa_debug.c feedback_snapshot.c rc_command.c
  group Doc
    ../X-CUBE-AI/App/: networkzn1_generate_report.txt
  group Lib
    ../Middlewares/ST/AI/Lib/: NetworkRuntime1020_CM7_Keil.lib
  group Application/User/X-CUBE-AI/App
    ./: 
    ../X-CUBE-AI/App/: networkzn1.c networkzn1_data.c networkzn1_data_params.c
software components: CMSIS:CORE 4.3.0
